/*
 * ============================================================================
 *  드론 추적 팬-틸트 : 아두이노 수신 뼈대 코드 (Arduino Uno R3)
 * ============================================================================
 *
 *  ■ 이 코드가 하는 일
 *    PC(비전)가 "드론이 화면 중앙에서 몇 도 떨어져 있는지"를 USB 시리얼로
 *    매 프레임(초당 약 30번) 보내줍니다. 이 코드는 그걸 받아서 숫자로 바꾼 뒤,
 *    아래 [제어부] 함수 3개 중 하나를 불러줍니다.
 *
 *      onTarget(ax, ay)  ← 드론이 보일 때 (새 메시지마다 1번)
 *      onLost()          ← 드론을 놓쳤을 때 (새 메시지마다 1번)
 *      onLinkTimeout()   ← PC에서 0.3초 넘게 아무것도 안 올 때 (끊긴 순간 1번)
 *
 *    → 제어 담당은 [제어부] 3개 함수 안만 채우면 됩니다.
 *      [수신부]는 건드리지 않아도 됩니다.
 *
 *  ■ PC가 보내는 메시지 형식 (글자로 옵니다)
 *
 *      <valid,ax,ay>
 *
 *      valid : 1 = 드론 탐지됨, 0 = 못 찾음
 *      ax    : 가로 각도 오차, 단위 0.1도 (정수).  + 면 드론이 화면 "오른쪽"
 *      ay    : 세로 각도 오차, 단위 0.1도 (정수).  + 면 드론이 화면 "아래쪽"
 *
 *      예) <1,250,-17>  → 드론이 오른쪽으로 25.0도, 위로 1.7도에 있음
 *          <1,0,0>      → 드론이 정확히 화면 중앙 (움직일 필요 없음)
 *          <0,0,0>      → 드론 안 보임
 *
 *      카메라 화각 기준 범위: ax 약 -440 ~ +440, ay 약 -285 ~ +285
 *
 *  ■ PC 없이 혼자 테스트하는 법
 *    1) 업로드 후 [툴 → 시리얼 모니터] 열기
 *    2) 오른쪽 아래 속도를 115200 baud 로 맞추기
 *    3) 입력창에 <1,200,0> 입력 후 엔터  → onTarget(200, 0) 이 불림
 *       <0,0,0> 입력 → onLost() 가 불림
 *       아무것도 안 보내고 0.3초 지나면 → onLinkTimeout() 이 불림
 *    ※ PC 프로그램을 돌릴 땐 시리얼 모니터를 꼭 닫아야 합니다.
 *       (포트는 한 프로그램만 열 수 있음)
 *
 *  ■ 기존 코드와 합칠 때 주의
 *    - setup(), loop() 는 하나씩만 있어야 합니다. 기존 코드 내용을
 *      아래 setup()/loop() 의 [기존 코드 넣는 곳] 에 옮겨 넣으세요.
 *    - Serial.begin() 속도는 반드시 115200 (PC와 같아야 함).
 *    - delay() 쓰지 마세요! delay 중엔 메시지를 못 읽어서 반응이 늦어집니다.
 *      시간 간격이 필요하면 millis() 로 하세요.
 *    - Serial.readString(), Serial.parseInt() 쓰지 마세요!
 *      최대 1초씩 멈춥니다. 수신은 아래 readSerial() 이 다 해줍니다.
 *    - Serial.print() 로 디버그 출력하는 건 괜찮습니다.
 *    - 서보/모터 전원은 아두이노 5V 핀 말고 외부 전원을 쓰고,
 *      외부 전원 GND 와 아두이노 GND 를 꼭 연결하세요.
 * ============================================================================
 */

#include <Servo.h>   // 서보 예시용. 스텝모터 등 다른 걸 쓰면 지워도 됨


// ============================================================================
//  [설정] 필요하면 숫자만 바꾸세요
// ============================================================================

const long          BAUD_RATE  = 115200;  // PC와 같아야 함. 바꾸지 마세요.
const unsigned long TIMEOUT_MS = 300;     // 이 시간(ms) 동안 메시지 없으면 끊긴 걸로 판단


// ============================================================================
//  [제어부]  ★ 제어 담당이 채우는 곳 ★
// ----------------------------------------------------------------------------
//  아래는 "서보 2개" 기준 예시가 들어 있습니다.
//  기존 코드가 있으면 예시를 지우고 기존 모터 코드로 바꾸면 됩니다.
// ============================================================================

// ---- 예시용 설정 (서보) ----
Servo pan, tilt;                 // pan = 좌우, tilt = 상하
const int   PAN_PIN  = 9;
const int   TILT_PIN = 10;
const float K        = 0.4;      // 오차의 몇 %만큼 한 번에 움직일지.
                                 //   1.0 이면 한 번에 다 가려다 진동함(카메라 지연 때문).
                                 //   떨리면 줄이고(0.2~0.3), 느리면 키우세요.
const int   DEADBAND = 15;       // 이 값(0.1도 단위) 이내 오차는 무시 → 1.5도. 미세 떨림 방지
const int   PAN_DIR  = 1;        // 드론 반대쪽으로 돌면 -1 로 바꾸기
const int   TILT_DIR = 1;        // 드론 반대쪽으로 돌면 -1 로 바꾸기
const float PAN_MIN  = 0,  PAN_MAX  = 180;   // 기구가 부딪히지 않는 각도 범위로 맞추기
const float TILT_MIN = 30, TILT_MAX = 150;
float panAngle  = 90;            // 현재 서보 각도 (시작은 가운데)
float tiltAngle = 90;


// 드론이 보일 때 불림. ax, ay 는 0.1도 단위 (예: 250 = 25.0도)
void onTarget(int ax, int ay) {
  // ---------- 예시 시작 (서보) : 기존 코드로 바꿔도 됨 ----------

  // 1) 0.1도 단위 → 도 단위로 바꾸기
  float errPanDeg  = ax / 10.0;
  float errTiltDeg = ay / 10.0;

  // 2) 오차가 충분히 클 때만, 오차의 K 비율만큼 각도를 조금 움직임
  if (abs(ax) > DEADBAND) panAngle  += PAN_DIR  * K * errPanDeg;
  if (abs(ay) > DEADBAND) tiltAngle += TILT_DIR * K * errTiltDeg;

  // 3) 기구 한계를 넘지 않게 자르기
  panAngle  = constrain(panAngle,  PAN_MIN,  PAN_MAX);
  tiltAngle = constrain(tiltAngle, TILT_MIN, TILT_MAX);

  // 4) 서보에 명령
  pan.write(round(panAngle));
  tilt.write(round(tiltAngle));

  // ---------- 예시 끝 ----------
}

// 드론을 놓쳤을 때 불림 (PC는 계속 연결되어 있음)
void onLost() {
  // 예: 그 자리에 가만히 있기 → 아무것도 안 해도 서보는 현재 각도를 유지함
  // 다른 동작을 원하면 여기에 (예: 천천히 좌우로 훑기, LED 켜기 등)
}

// PC에서 TIMEOUT_MS 넘게 메시지가 안 올 때 불림 (프로그램 종료, 케이블 빠짐 등)
void onLinkTimeout() {
  // 예: 안전하게 정지. 서보는 아무것도 안 하면 제자리 유지.
  // DC/스텝모터라면 여기서 반드시 모터를 멈추세요!
}


// ============================================================================
//  [수신부]  건드리지 않아도 됩니다
// ----------------------------------------------------------------------------
//  시리얼로 들어오는 글자를 하나씩 모아서 '<' ~ '>' 사이가 완성되면
//  숫자 3개로 바꿉니다. 메시지가 조각나서 와도 괜찮고, 기다리지 않습니다.
// ============================================================================

char buf[24];                  // '<' 와 '>' 사이 글자를 모으는 곳
byte bufLen = 0;
bool inMsg = false;            // 지금 '<' 를 받고 메시지를 모으는 중인지

bool newMsg = false;           // 새 메시지가 완성됐는지
int  rxValid = 0, rxAx = 0, rxAy = 0;
unsigned long lastRxTime = 0;  // 마지막으로 올바른 메시지를 받은 시각
bool linkAlive = false;        // 현재 PC와 연결된 상태인지

void readSerial() {
  while (Serial.available() > 0) {          // 버퍼에 쌓인 글자를 전부 처리
    char c = Serial.read();

    if (c == '<') {                         // 시작 표시 → 새로 모으기 시작
      inMsg = true;
      bufLen = 0;
    }
    else if (c == '>' && inMsg) {           // 끝 표시 → 숫자로 바꾸기
      buf[bufLen] = '\0';
      inMsg = false;
      int v, x, y;
      // "1,250,-17" → v=1, x=250, y=-17.  형식이 이상하거나 범위를 벗어나면 버림
      if (sscanf(buf, "%d,%d,%d", &v, &x, &y) == 3 &&
          (v == 0 || v == 1) && abs(x) <= 900 && abs(y) <= 900) {
        rxValid = v;
        rxAx = x;
        rxAy = y;
        newMsg = true;
        lastRxTime = millis();
      }
    }
    else if (inMsg) {                       // 중간 글자 → 모으기
      if (bufLen < sizeof(buf) - 1) buf[bufLen++] = c;
      else inMsg = false;                   // 너무 길면 잘못된 메시지 → 버림
    }
    // '<' 밖의 글자(줄바꿈 등)는 무시
  }
}

// 받은 메시지에 따라 [제어부] 함수를 불러줌
void handleMessage() {
  // 1) 연결 끊김 검사
  if (millis() - lastRxTime > TIMEOUT_MS) {
    if (linkAlive) {                        // 방금 끊겼으면 한 번만 알림
      linkAlive = false;
      onLinkTimeout();
    }
    newMsg = false;
    return;
  }
  linkAlive = true;

  // 2) 새 메시지가 왔을 때만 한 번 처리
  //    (loop 는 초당 수천 번 돌지만 메시지는 초당 30번 → 같은 값으로 여러 번 움직이면 안 됨)
  if (newMsg) {
    newMsg = false;
    if (rxValid == 1) onTarget(rxAx, rxAy);
    else              onLost();
  }
}


// ============================================================================
//  setup / loop
// ============================================================================

void setup() {
  Serial.begin(BAUD_RATE);

  // ---- 예시(서보) 초기화 : 기존 코드로 바꿔도 됨 ----
  pan.attach(PAN_PIN);
  tilt.attach(TILT_PIN);
  pan.write(round(panAngle));
  tilt.write(round(tiltAngle));

  // ---- [기존 코드 넣는 곳] 기존 setup() 내용 (Serial.begin 은 빼고) ----
}

void loop() {
  readSerial();      // 1) 들어온 글자 읽기       ← 꼭 매번 호출
  handleMessage();   // 2) 완성된 메시지 처리     ← 꼭 매번 호출

  // ---- [기존 코드 넣는 곳] 기존 loop() 내용 ----
  // 주의: delay() 쓰지 말 것. 오래 걸리는 작업이 있으면 millis() 로 나눠서.
}
